# Keil uVision project catos.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: catos
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\User;..\rtthread\3.0.3\include
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group user
    ../User/: main.c
  group doc
    ../Doc/: readme.txt
  group rtt/ports
    ../rtthread/3.0.3/libcpu/arm/cortex-m3/: context_rvds.S
  group rtt/source
    ../rtthread/3.0.3/include/: rtdef.h rtconfig.h rtservice.h rtthread.h rthw.h
    ../rtthread/3.0.3/src/: thread.c scheduler.c
    ../rtthread/3.0.3/libcpu/arm/cortex-m3/: cpuport.c
software components: CMSIS:CORE 5.3.0, Device:Startup 1.2.0
